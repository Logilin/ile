## exemples/chapitre-03/hello-custom/Config.in
```kconfig
config BR2_PACKAGE_HELLO_CUSTOM
	bool "Hello Custom"
	help
	  Our custom Hello program.

	  https://www.logilin.fr/
```
